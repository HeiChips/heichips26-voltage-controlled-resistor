v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -50 0 -30 0 {lab=net1}
N 30 0 50 0 {lab=net1}
C {devices/iopin.sym} -50 0 2 0 {name=p61 lab=net1}
C {devices/iopin.sym} 50 0 0 0 {name=p1 lab=net2}
C {vsource.sym} 0 0 1 0 {name=V1 value=0 savecurrent=false}
